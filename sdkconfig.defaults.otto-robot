## sdkconfig.defaults.ricky-boy
```kconfig
CONFIG_BOARD_TYPE_RICKY_BOY=y
CONFIG_PARTITION_TABLE_CUSTOM_FILENAME="partitions/v2/16m_otto_robot.csv"
```
